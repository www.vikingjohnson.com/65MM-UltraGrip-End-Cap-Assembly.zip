# Autodesk Inventor part: 65mm
## iProperties
Created: 2012-04
Part Number: 65mm
Document SubType Name: Modeling
Designer: D Cole
Density: 1 g/cm^3
Author: D Cole
